# Keil uVision project v0.uvproj, settings and files
target Target 1 (166/167)
  device: C164CI Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) CLOCK(20000000) IROM (0-0xFFFF) ICAN(0xE800-0xEFFF) MOD167
  output: v0 +hex
  group Dave Files
    ./: Start167.a66 MAIN.C CONF_TNY.A66
